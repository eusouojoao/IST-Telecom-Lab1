options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19500'
    low_cutoff_freq: '18500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1000'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '25'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joao/Documents/MEEC/3o ano/1 sem/Telecom/Lab/Lab1/Testes/LEFT_POSD_1000Hz.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: '125000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: nota_2
  id: note
  parameters:
    note: O PROBLEMA ESTÁ AQUI
  states: {}
- name: nota_2_0
  id: note
  parameters:
    note: DSB-SC L-R
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"File source"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"L + R e L - R"'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"L-R (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"DSB-SC L-R (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"Piloto (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_1
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"L+R (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    label1: R
    label2: '''L'''
    name: '"L e R together"'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_4_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    name: '"L"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_4_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    name: '"R"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_4_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Squared pilot (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"L-R (time domain)"'
    size: '5000'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"L+R (time domain)"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"L + R e L - R"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: ''
    label2: ''
    name: '"Squared pilot (time domain)"'
    size: '5000'
    srate: samp_rate
    style2: '5'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    label1: L
    name: '"L "'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: R
    name: '"R"'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '48'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: piloto 2x
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mensagem
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: piloto 2x
  states: {state: disabled}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: piloto 2x
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_4_1
  id: virtual_source
  parameters:
    stream_id: L - R
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '1']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_2_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_2_0, '0']
- [band_pass_filter_0_1, '0', virtual_sink_0_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_2, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_1, '0', blocks_delay_0, '0']
- [low_pass_filter_2, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '1']
- [rational_resampler_xxx_1, '0', blocks_null_sink_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_3, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_4_0_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_time_sink_x_1_1_0, '0']
- [rational_resampler_xxx_1_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_null_sink_0, '1']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_3, '1']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_4_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_time_sink_x_1_1, '0']
- [virtual_source_0, '0', low_pass_filter_1, '0']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', band_pass_filter_0_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_4_1, '0']
- [virtual_source_2, '0', qtgui_time_sink_x_1_0_0, '0']
- [virtual_source_2_0, '0', blocks_add_xx_0, '0']
- [virtual_source_2_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_1, '1']
- [virtual_source_4, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_2_1, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_4, '0', qtgui_time_sink_x_1_0, '0']
- [virtual_source_4_0, '0', qtgui_freq_sink_x_1, '1']
- [virtual_source_4_0, '0', qtgui_freq_sink_x_2, '0']
- [virtual_source_4_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_4_0, '0', qtgui_time_sink_x_1_0, '1']
- [virtual_source_4_1, '0', blocks_add_xx_0, '1']
- [virtual_source_4_1, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-244-g7c7894df
