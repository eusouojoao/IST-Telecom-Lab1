options:
  parameters:
    generate_options: qt_gui
    id: Desmodulacao_FM_Stereo
    output_language: python
    title: Desmodulacao_FM_Stereo
  states: {}

blocks:
- name: FM_station
  id: variable
  parameters:
    value: '104300000'
  states: {}
- name: PI
  id: variable
  parameters:
    value: '3.14159265359'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.00065'
  states: {}
- name: maxps
  id: variable
  parameters:
    value: 2*PI*19500/samp_rate
  states: {}
- name: minps
  id: variable
  parameters:
    value: 2*PI*18500/samp_rate
  states: {}
- name: ratio
  id: variable
  parameters:
    value: '125'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: ratio*1000
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_1
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: maxps
    min_freq: minps
    w: loop_bw
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    comment: Desmodulação do sinal FM
    quad_rate: '500000'
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: Descoberta e regeneração da sinusoide piloto
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '400'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '2'
    high_cutoff_freq: '38500'
    low_cutoff_freq: '37500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    comment: |-
      Compensar o delay induzido 
      pelos filtros no ramo que 
      recupera o sinal L-R
    delay: '25'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joao/Documents/MEEC/3o ano/1 sem/Telecom/Lab/telecom-lab1/test_files/IQ_104,3MHz.dat
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    comment: |-
      Os sinais de teste LEFT e RIGHT
      já vêm desmodulados, é apenas
      necessária a descodificação da
      mensagem
    file: /home/joao/Documents/MEEC/3o ano/1 sem/Telecom/Lab/telecom-lab1/test_files/RIGHT_POSD_2000Hz.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    comment: |-
      Recuperação do sinal L-R
      (Coherent detector)
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    comment: |-
      Auxiliar, serve para que as duas 
      formas de regeneração do sinal 
      piloto coexistam
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: '500000'
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      125 -> Sinais de teste LEFT & RIGHT
      500 -> Sinal de teste IQ e transmissões radio
    note: Só alterar o ratio!!!
  states: {}
- name: note_1
  id: note
  parameters:
    note: Ganho 4 para PLL
  states: {}
- name: note_2
  id: note
  parameters:
    note: Ganho 400 tradicional
  states: {}
- name: note_3
  id: note
  parameters:
    note: '2R '
  states: {}
- name: note_4
  id: note
  parameters:
    note: 2L
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: PLL
    label2: Tradicional
    name: '"Portadoras regeneradas (freq. domain)"'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: PLL
    label2: Tradicional
    name: '"Portadoras regeneradas (time domain)"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: FM_station
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '1'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: MSG
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: Portadora 2x freq PLL
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Portadora 2x freq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L + R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Portadora 2x freq PLL
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: Descodificação do sinal stereo
    stream_id: MSG
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    comment: Descodificação do sinal mono
    stream_id: MSG
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    comment: |-
      Dematrixing
      [L-R] + [L+R] = 2L
      [L+R] - [L-R] = 2R
    stream_id: L + R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    comment: |-
      Renomear consoante o modo de
      regeneração do sinal piloto
      preferido
    stream_id: Portadora 2x freq
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L - R
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: Portadora 2x freq
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_2, '0']
- [analog_fm_deemph_1, '0', low_pass_filter_1, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_wfm_rcv_0, '0', virtual_sink_0, '0']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_1, '0']
- [band_pass_filter_0_1, '0', virtual_sink_0_0, '0']
- [band_pass_filter_0_1_0, '0', virtual_sink_0_0_0, '0']
- [band_pass_filter_0_2, '0', blocks_multiply_xx_2, '0']
- [band_pass_filter_0_2, '0', blocks_multiply_xx_2, '1']
- [blocks_add_xx_0, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_real_0, '0', band_pass_filter_0_1, '0']
- [blocks_delay_1, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_1, '0', virtual_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_1, '0', analog_fm_deemph_0, '0']
- [blocks_multiply_xx_2, '0', band_pass_filter_0_1_0, '0']
- [blocks_sub_xx_0, '0', rational_resampler_xxx_1_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_delay_1, '0']
- [low_pass_filter_2, '0', virtual_sink_2, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_0, '0']
- [rational_resampler_xxx_1_0, '0', audio_sink_0, '1']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', blocks_null_sink_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_1, '0', band_pass_filter_0, '0']
- [virtual_source_1, '0', band_pass_filter_0_0, '0']
- [virtual_source_1, '0', band_pass_filter_0_2, '0']
- [virtual_source_1_0, '0', analog_fm_deemph_1, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '1']
- [virtual_source_2, '0', blocks_sub_xx_0, '0']
- [virtual_source_3, '0', blocks_multiply_xx_1, '1']
- [virtual_source_4, '0', blocks_add_xx_0, '0']
- [virtual_source_4, '0', blocks_sub_xx_0, '1']
- [virtual_source_5, '0', blocks_null_sink_0, '1']
- [virtual_source_5, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_5, '0', qtgui_time_sink_x_1, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
