options:
  parameters:
    generate_options: qt_gui
    id: DesmodulacaoFM_STEREO
    output_language: python
    title: 'Desmodulação FM STEREO '
  states: {}

blocks:
- name: FM_station
  id: variable
  parameters:
    value: '104300000'
  states: {}
- name: ratio
  id: variable
  parameters:
    value: '125'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: '0.238886'
    min_freq: '0.238635'
    w: '0.00065'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    deemph_tau: '75e-6'
    quad_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '19500'
    low_cutoff_freq: '18500'
    samp_rate: samp_rate
    type: fir_filter_fcc
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '53000'
    low_cutoff_freq: '23000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '39000'
    low_cutoff_freq: '37000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joao/Documents/MEEC/3o ano/1 sem/Telecom/Lab/Lab1/Testes/LEFT_POSD_1000Hz.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/joao/Documents/MEEC/3o ano/1 sem/Telecom/Lab/Lab1/Testes/IQ_104,3MHz.dat
    repeat: 'True'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '30000'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: DSB-SC com L-R
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'Piloto de  19kHz '
  states: {}
- name: note_2
  id: note
  parameters:
    note: Recuperar L-R
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    name: '"Frequency plot"'
    nconnections: '2'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"DSB-SC L-R (freq. domain)"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Double freq. pilot (freq. domain)"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"L+R"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"L-R"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"PLL regenerated carrier"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: ratio
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: FM_station
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '2000000'
    sync: sync
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: DSB-SC_L-R
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: MSG
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: MSG
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: DSB-SC_L-R
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_pll_refout_cc_0, '0', qtgui_freq_sink_x_3, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [analog_wfm_rcv_0, '0', virtual_sink_0_0, '0']
- [band_pass_filter_0, '0', analog_pll_refout_cc_0, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_1, '0']
- [band_pass_filter_1, '0', virtual_sink_0, '0']
- [band_pass_filter_2, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_1, '0', band_pass_filter_2, '0']
- [blocks_complex_to_real_1, '0', qtgui_freq_sink_x_2, '0']
- [blocks_file_source_0, '0', low_pass_filter_1, '0']
- [blocks_file_source_0, '0', virtual_sink_0_0, '0']
- [blocks_file_source_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_1, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_2, '0']
- [blocks_sub_xx_0, '0', audio_sink_0, '1']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_2, '0', rational_resampler_xxx_1_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_1, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_1_0, '0', virtual_sink_2, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']
- [virtual_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', band_pass_filter_1, '0']
- [virtual_source_1, '0', blocks_multiply_xx_1, '1']
- [virtual_source_2, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_sub_xx_0, '0']
- [virtual_source_2, '0', qtgui_freq_sink_x_2_0, '0']
- [virtual_source_3, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_sub_xx_0, '1']
- [virtual_source_3, '0', qtgui_freq_sink_x_2_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-244-g7c7894df
